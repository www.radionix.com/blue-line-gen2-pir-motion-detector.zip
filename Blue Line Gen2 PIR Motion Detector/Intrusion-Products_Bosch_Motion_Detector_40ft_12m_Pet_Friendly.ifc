Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
Time: 2023-12-22T14:26:45
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.1.30.34 - Alternate UI 22.1.30.34

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_SiteCommon - Reference: Informações do projeto
Outros - Categoria: Informações do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informações do projeto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informações do projeto; sets with these values: 2
Outros - Categoria: Informações do projeto

# IfcBuildingStorey: Nível:Nível 1, Nível 1
LongName: Nível 1; Elevation: 0 ft
Pset_BuildingStoreyCommon - Reference: Nível 1
Cotas - Cálculo da altura: 0 ft
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Nível 1; ID de tipo: 1813; Tipo: Nível 1
Restrições - Elevação: 0 ft
Dados de identidade(Type) - Nome do tipo: Nível 1
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Sólido; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Restrições(Type) - Base da elevação: Ponto base do projeto

# IfcBuildingElementProxy: D_Detection Field ISC-BPR2-WP12 2:Standard, D_Detection Field ISC-BPR2-WP12 2:Standard:122507
In: Nível 1
Type - Material: Xtech_Bosch_ABS_White
Type - Dados de identidade - Nome do tipo: Standard
Type - Materiais e acabamentos - Lens Material: I_Bosch
Type - Mecânica - Classificação: Nenhum
Type - Outros - Categoria: Equipamento mecânico; Nome da família: D_Detection Field ISC-BPR2-WP12 2
Type - Restrições - Elevação-padrão: 6.56168 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 0.000336372 ft2; Volume: 0.00988638 ft3
Dados de identidade - Marca: 7
Fases - Fase criada: Construção nova
Geral - BDesired: 0 ft; FDesired: 39.3701 ft; LDesired: 13.1234 ft; Lower FOV Limit Desired: 6.56168 ft; RDesired: 13.1234 ft; Upper FOV Limit Desired: 8.85827 ft
Materiais e acabamentos - Lens Material 2: I_Bosch2; Material: Bosch_RAL9003
Outros - Família: D_Detection Field ISC-BPR2-WP12 2; Família e tipo: D_Detection Field ISC-BPR2-WP12 2: Standard; ID de tipo: 106791; Tipo: Standard
Restrições - Deslocamento do hospedeiro: 0 ft; Elevação do nível: 0 ft; Move com elementos próximos: no; Nível: Nível 1; Distance to Object: 0.328084 ft; DORI: yes; FOVActual Horizontal Angle: 100 deg; FOV Pan Actual: 0 deg; FOV Tilt Actual1: -30 deg; FOV Tilt Actual2: 74 deg; Hospedeiro: Nível : Nível 1; Show Manual Field of View: yes; Upright Angle: 0 deg; z Angle Pan Actual: 0 deg; z Angle Tilt Actual: 30 deg; z Angle Tilt Actual 2: -74 deg

# IfcBuildingElementProxy: Detection Field ISC-BPR2-WP12 1:Standard, Detection Field ISC-BPR2-WP12 1:Standard:122508
In: Nível 1
Type - Material: R_Bosch, I_Bosch
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Detection Field ISC-BPR2-WP12 1
Type - Restrições - Elevação-padrão: 4 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 5082.75 ft2; D_Distance: 2310 ft; EndCtrl: 47 deg; FOVDistance: 13.1234 ft; FOVVer: 61.5625 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 231 ft; O_Distance: 916.667 ft; R_Distance: 462 ft; Rad: 0.00351827 ft; StartCtrl: -47 deg; VoidDist: 2310.25 ft; Volume: 24657 ft3
Fases - Fase criada: Construção nova
Geometria da divisão - BackAct: 7500 ft; Base: 7500 ft; BottAct: 7493.44 ft; FrontAct: 7460.63 ft; LeftAct: 7486.88 ft; RightAct: 7486.88 ft; TopAct: 7491.14 ft
Geral - BDesired: 0 ft; BoDesired: 6.56168 ft; FDesired: 39.3701 ft; LDesired: 13.1234 ft; RDesired: 13.1234 ft; TDesired: 8.85827 ft
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Tilt: -30 deg; Visible: no
Materiais e acabamentos - Material: I_Bosch
Outros - DORI: yes; Tipo: Standard; Família: Detection Field ISC-BPR2-WP12 1; Família e tipo: Detection Field ISC-BPR2-WP12 1: Standard; ID de tipo: 106760; ManualFOV: yes
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 0.347125 ft; Elevação do nível: 0.347125 ft; Hospedeiro: Nível : Nível 1

# IfcBuildingElementProxy: Detection Field ISC-BPR2-WP12 2:Standard, Detection Field ISC-BPR2-WP12 2:Standard:122509
In: Nível 1
Type - Material: I_Bosch2, R_Bosch2
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Detection Field ISC-BPR2-WP12 2
Type - Restrições - Elevação-padrão: 4 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 523.824 ft2; D_Distance: 2310 ft; EndCtrl: 47 deg; FOVDistance: 13.1234 ft; FOVVer: 74.7812 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 231 ft; O_Distance: 916.667 ft; R_Distance: 462 ft; Rad: 0.00351827 ft; StartCtrl: -47 deg; VoidDist: 2310.25 ft; Volume: 843.36 ft3
Fases - Fase criada: Construção nova
Geometria da divisão - BackAct: 7500 ft; Base: 7500 ft; BottAct: 7491.14 ft; FrontAct: 7460.63 ft; LeftAct: 7486.88 ft; RightAct: 7486.88 ft; TopAct: 7493.44 ft
Geral - BDesired: 0 ft; BoDesired: 8.85827 ft; FDesired: 39.3701 ft; LDesired: 13.1234 ft; RDesired: 13.1234 ft; TDesired: 6.56168 ft
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Visible: no; Tilt: 74 deg
Materiais e acabamentos - Material 2: I_Bosch2
Outros - DORI: yes; Tipo: Standard; ManualFOV: yes; Família: Detection Field ISC-BPR2-WP12 2; Família e tipo: Detection Field ISC-BPR2-WP12 2: Standard; ID de tipo: 106823
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 0.602472 ft; Elevação do nível: 0.602472 ft; Hospedeiro: Nível : Nível 1

# IfcSensor: Motion Detector 40ft (12m) Pet Friendly, Intrusion-Products_Bosch_Motion_Detector_40ft_12m_Pet_Friendly:Motion_Detector_40ft_12m_Pet_Friendly:122506
In: Nível 1
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_75_80_42_16 Combined passive infrared and microwave movement detectors (Uniclass 2015); Material: Bosch_Withe
Type - Cotas - 2DSymbolOffset: 0 ft; Dimension depth (mm): 44; Dimension height (mm): 105; Dimension width (mm): 61
Type - Dados de identidade - Descrição: Motion Detector 40ft (12m) Pet Friendly; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; Fabricante: Bosch Security and Safety Systems; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/BlueLine_Gen_2_WP12_Installation_Manual_all_2603182859.pdf; Nome do tipo: Motion_Detector_40ft_12m_Pet_Friendly; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/BlueLine_Gen_2_WP12_Installation_Manual_all_2603182859.pdf; ProductInformation: https://resources-boschsecurity-cdn.azureedge.net/public/documents/BlueLine_Gen_2_Data_sheet_enUS_2603228171.pdf; ProductMaterial: Plastic; URL: https://www.boschsecurity.com; Version: 1
Type - Geral - Detection range (max): 12m x12m; Detector type: PIR; Environmental class: EN50130-5 Class II; IK Class: IK04; IP Class: IP30; Microwave frequency: 150 kHz to 2 GHz; Operating temperature (°C) (maximum): 55; Operating temperature (°C) (minimum): -30; Operating voltage (VDC) (maximum): 15; Operating voltage (VDC) (minimum): 9; Pet immunity: One or two pets up to 20 kg (45 lb) ornumerous rodents
Type - Materiais e acabamentos - Color: White
Type - Outros - Categoria: Dispositivos de segurança; Nome da família: Intrusion-Products_Bosch_Motion_Detector_40ft_12m_Pet_Friendly
Type - Restrições - Elevação padrão: 0 ft; XDetHor: 0 ft; XDetVer: 0.134514 ft
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Pset_EnvironmentalImpactIndicators - Reference: Motion_Detector_40ft_12m_Pet_Friendly; sets with these values: 2
Construção - B328 Mounting bracket, gimbal: yes; B335-3 Mounting bracket, swivel, low profile: yes; B338 Mounting bracket, ceiling, universal: yes; Detection Range: 39.3701 ft; FrontDimension: 39.3701 ft; Mount Part Number: none
Cotas - Área: 1.51193 ft2; Volume: 0.00405492 ft3
Dados de identidade - CTN: ISC-BPR2-WP12 & B335-3 & B338 & B328; Marca: 7; Material number: F.01U.382.959 & 4.998.800.014 & 4.998.800.282 & 4.998.800.277
Fases - Fase criada: Construção nova
Gráficos - Actual Tilt: 30 deg; Actual Tilt 2: -74 deg; DF Actual Horizontal Angle: 103 deg; DF Desired Horizontal Angle: 103 deg; Lower DF Limit: 8.85827 ft; Lower DF Limit Desired: 8.85827 ft; Show Detection Field: yes; Upper DF Limit Desired: 6.56168 ft
Outros - Família: Intrusion-Products_Bosch_Motion_Detector_40ft_12m_Pet_Friendly; Família e tipo: Intrusion-Products_Bosch_Motion_Detector_40ft_12m_Pet_Friendly: Motion_Detector_40ft_12m_Pet_Friendly; ID de tipo: 122477; Tipo: Motion_Detector_40ft_12m_Pet_Friendly
Restrições - Deslocamento do hospedeiro: 0 ft; Elevação do nível: 0 ft; Hospedeiro: Nível : Nível 1; Move com elementos próximos: no; Nível: Nível 1; XDetectionField: yes; XVisDet: no
Visibilidade - Flipped Position: no; Original Position: yes
