Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: 0001
Time: 2024-01-18T16:26:08+00:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - IU alternativa 23.0.11.19

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Pset_SiteCommon - Reference: Informações do projeto
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informações do projeto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informações do projeto; sets with these values: 2
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Cabeça de 8 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Dimensões - Cálculo da altura: 0 mm
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 349; Tipo: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Restrições(Type) - Base da elevação: Ponto base do projeto

# IfcBuildingElementProxy: Blue Line Gen2 PIR Motion Detectors, Intrusion-Products_Bosch_Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12:Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12:309875
In: Nível 1
Type - Classification: Pr_75_80_42_16 Combined passive infrared and microwave movement detectors (Uniclass 2015); Material: Bosch_Withe
Type - Dados de identidade - Descrição: Blue Line Gen2 PIR Motion Detectors; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; Fabricante: Bosch Security and Safety Systems; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/BlueLine_Gen_2_W12_Installation_Manual_enUS_2603159435.pdf; Nome do tipo: Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/BlueLine_Gen_2_W12_Installation_Manual_enUS_2603159435.pdf; ProductInformation: https://resources-boschsecurity-cdn.azureedge.net/public/documents/ISC_BPQ2_W12_Data_sheet_enUS_2603527307.pdf; ProductMaterial: Plastic; URL: https://www.boschsecurity.com; Version: 1
Type - Dimensões - 2DSymbolOffset: 0 mm; Dimension depth (mm): 44; Dimension height (mm): 105; Dimension width (mm): 61
Type - Geral - Detection range (max): 12m x12m; Detector type: PIR; Environmental class: EN50130-5 Class II; IK Class: IK04; IP Class: IP30; Microwave frequency: 150 kHz to 2 GHz; Operating temperature (°C) (maximum): 55; Operating temperature (°C) (minimum): -30; Operating voltage (VDC) (maximum): 15; Operating voltage (VDC) (minimum): 9
Type - Materiais e acabamentos - Color: White
Type - Outros - Categoria: Dispositivos de segurança; Nome da família: Intrusion-Products_Bosch_Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12
Type - Restrições - Elevação padrão: 0 mm; XDetHor: 0 mm; XDetVer: 41 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Pset_BuildingElementProxyCommon - Reference: Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12
Pset_EnvironmentalImpactIndicators - Reference: Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12
Construção - B328 Mounting bracket, gimbal: yes; B335-3 Mounting bracket, swivel, low profile: yes; B338 Mounting bracket, ceiling, universal: yes; Detection Range: 12000 mm; FrontDimension: 12000 mm; Mount Part Number: none
Dados de identidade - CTN: ISC-BPQ2-W12 & B335-3 & B338 & B328; Marca: 1; Material number: F.01U.364.871 & 4.998.800.014 & 4.998.800.282 & 4.998.800.277
Dimensões - Área: 0.140463 m2; Volume: 0.000114823 m3
Fases - Fase criada: Fase 1
Gráficos - Actual Tilt: 30 deg; Actual Tilt 2: -74 deg; DF Actual Horizontal Angle: 103 deg; DF Desired Horizontal Angle: 103 deg; Lower DF Limit: 2700 mm; Lower DF Limit Desired: 2700 mm; Show Detection Field: yes; Upper DF Limit Desired: 2000 mm
Outros - Família: Intrusion-Products_Bosch_Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12; Família e tipo: Intrusion-Products_Bosch_Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12: Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12; ID de tipo: 309846; Tipo: Blue_Line_Gen2_PIR_Motion_Detectors_ISC-BPQ2-W12
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Move com elementos próximos: no; Nível: Nível 1; XDetectionField: yes; XVisDet: no
Visibilidade - Flipped Position: no; Original Position: yes

# IfcBuildingElementProxy: D_Detection Field ISC-BPQ2-WP12 2:Standard, D_Detection Field ISC-BPQ2-WP12 2:Standard:309876
In: Nível 1
Type - Material: Xtech_Bosch_ABS_White
Type - Dados de identidade - Nome do tipo: Standard
Type - Materiais e acabamentos - Lens Material: I_Bosch
Type - Mecânica - Classificação: Nenhum
Type - Outros - Categoria: Equipamento mecânico; Nome da família: D_Detection Field ISC-BPQ2-WP12 2
Type - Restrições - Elevação-padrão: 2000 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Dados de identidade - Marca: 1
Dimensões - Área: 0.00003125 m2; Volume: 0.000279951 m3
Fases - Fase criada: Fase 1
Geral - BDesired: 0 mm; FDesired: 12000 mm; LDesired: 4000 mm; Lower FOV Limit Desired: 2000 mm; RDesired: 4000 mm; Upper FOV Limit Desired: 2700 mm
Materiais e acabamentos - Lens Material 2: I_Bosch2; Material: Bosch_RAL9003
Outros - Família: D_Detection Field ISC-BPQ2-WP12 2; Família e tipo: D_Detection Field ISC-BPQ2-WP12 2: Standard; ID de tipo: 309437; Tipo: Standard
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Move com elementos próximos: no; Nível: Nível 1; Distance to Object: 100 mm; DORI: yes; FOVActual Horizontal Angle: 100 deg; FOV Pan Actual: 0 deg; FOV Tilt Actual1: -30 deg; FOV Tilt Actual2: 74 deg; Hospedeiro: Nível : Nível 1; Show Manual Field of View: yes; Upright Angle: 0 deg; z Angle Pan Actual: 0 deg; z Angle Tilt Actual: 30 deg; z Angle Tilt Actual 2: -74 deg

# IfcBuildingElementProxy: Detection Field ISC-BPQ2-WP12 1:Standard, Detection Field ISC-BPQ2-WP12 1:Standard:309877
In: Nível 1
Type - Material: R_Bosch, I_Bosch
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Detection Field ISC-BPQ2-WP12 1
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Dimensões - Área: 472.203 m2; D_Distance: 704089 mm; EndCtrl: 47 deg; FOVDistance: 4000 mm; FOVVer: 61.5625 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 70408.9 mm; O_Distance: 279400 mm; R_Distance: 140818 mm; Rad: 1.07237 mm; StartCtrl: -47 deg; VoidDist: 704165 mm; Volume: 698.209 m3
Fases - Fase criada: Fase 1
Geometria da divisão - BackAct: 2286000 mm; Base: 2286000 mm; BottAct: 2284000 mm; FrontAct: 2274000 mm; LeftAct: 2282000 mm; RightAct: 2282000 mm; TopAct: 2283300 mm
Geral - BDesired: 0 mm; BoDesired: 2000 mm; FDesired: 12000 mm; LDesired: 4000 mm; RDesired: 4000 mm; TDesired: 2700 mm
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Tilt: -30 deg; Visible: no
Materiais e acabamentos - Material: I_Bosch
Outros - DORI: yes; Tipo: Standard; Família: Detection Field ISC-BPQ2-WP12 1; Família e tipo: Detection Field ISC-BPQ2-WP12 1: Standard; ID de tipo: 309406; ManualFOV: yes
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 105.804 mm; Elevação do nível: 105.804 mm; Hospedeiro: Nível : Nível 1

# IfcBuildingElementProxy: Detection Field ISC-BPQ2-WP12 2:Standard, Detection Field ISC-BPQ2-WP12 2:Standard:309878
In: Nível 1
Type - Material: I_Bosch2, R_Bosch2
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Detection Field ISC-BPQ2-WP12 2
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Dimensões - Área: 48.6649 m2; D_Distance: 704089 mm; EndCtrl: 47 deg; FOVDistance: 4000 mm; FOVVer: 74.7812 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 70408.9 mm; O_Distance: 279400 mm; R_Distance: 140818 mm; Rad: 1.07237 mm; StartCtrl: -47 deg; VoidDist: 704165 mm; Volume: 23.8813 m3
Fases - Fase criada: Fase 1
Geometria da divisão - BackAct: 2286000 mm; Base: 2286000 mm; BottAct: 2283300 mm; FrontAct: 2274000 mm; LeftAct: 2282000 mm; RightAct: 2282000 mm; TopAct: 2284000 mm
Geral - BDesired: 0 mm; BoDesired: 2700 mm; FDesired: 12000 mm; LDesired: 4000 mm; RDesired: 4000 mm; TDesired: 2000 mm
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Visible: no; Tilt: 74 deg
Materiais e acabamentos - Material 2: I_Bosch2
Outros - DORI: yes; Tipo: Standard; ManualFOV: yes; Família: Detection Field ISC-BPQ2-WP12 2; Família e tipo: Detection Field ISC-BPQ2-WP12 2: Standard; ID de tipo: 309469
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 183.633 mm; Elevação do nível: 183.633 mm; Hospedeiro: Nível : Nível 1
